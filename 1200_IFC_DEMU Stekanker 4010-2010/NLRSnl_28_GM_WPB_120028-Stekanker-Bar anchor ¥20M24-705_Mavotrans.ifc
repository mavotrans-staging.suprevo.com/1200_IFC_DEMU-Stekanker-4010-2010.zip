Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-11-04T09:12:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 04 09:12:08 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{7064D80E-64D4-4980-9245-CB84581CF33E}\ifc * Database version: 5507 * Database creation date: Fri Nov 04 09:12:08 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 04 09:12:08 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 04 09:12:08 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\1200_DEMU Stekanker 4010-2010; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\1200_DEMU Stekanker 4010-2010; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 120028, NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19:120028_Ø20/M24-705:328045
In: Level 0
Type - Description: DEMU Stekanker | Bar anchor 4010 Ø20 M24 705mm; Classification: 28 (Default Classification); Material: B500B volgens EN 10080/NEN 6008, elektrolytisch verzinkt(1)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a min. (mm): 38 mm; b (mm): 32 mm; d_nom: M24; L (mm): 705 mm; Lengte tolerantie | Tolerance length: +/- 20mm; Ø (mm): 20 mm; Type: 4010
Type - Fire Protection - Brandklasse | Fire classification: Niet getest | Not tested
Type - Forces - Ontwerpbelasting | DesignLoads (Nrd,s): 136.60 kN
Type - Identity Data - Artikelnummer | Article number: 120028; Beschrijving | Description: DEMU Stekanker | Bar anchor 4010 Ø20 M24 705mm; Certificaten | Certification: KOMO cat 1. K7044 + KOMO cat 2. K53316 + Eurocode 2; Laatste versie | Last version: 04-11-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 28.20; OmniClass Number: 23.25.10.27.11.11; OmniClass Title: Reinforcing Steel; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 120028_Ø20/M24-705; URL: https://mavotrans.nl/demu-stekanker-4010-2010.html; Verpakkingshoeveelheid | Sales Packaging: Verkoop per stuk | Sold per piece; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022
Type - Materials and Finishes - Materiaal | Material: Draadbus galvanisch verzinkt + betonstaal B500B | Socket galvanized + steel B500B
Type - Other - Category: Generic Models; Diameter end bar anchor "b": 32 mm; Diameter end rebar "M": 24 mm; Diameter rebar "Ø": 20 mm; embrace: 47 mm; Family Name: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19; l (buslengte): 90 mm; Length bar anchor "L": 705 mm; length bus: 90 mm; Length end bar anchor "a": 38 mm; radius "b": 16 mm; radius "M": 12 mm; Radius "Ø": 10 mm; Radius "Ø" rebar end: 12.5 mm; transition: 5 mm
Type - Pset_ProductRequirements - Category: Generic Models
Material: B500B volgens EN 10080/NEN 6008, elektrolytisch verzinkt(1), Galvanized (GV)
Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19:120028_Ø20/M24-705; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0282135 m2; Volume: 0.000249166 m3
Other - Family: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19: 120028_Ø20/M24-705; Family and Type: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19: 120028_Ø20/M24-705; Schedule Level: Level: Level 0; Type: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19: 120028_Ø20/M24-705; Type Id: NLRSnl_28_GM_WPB_1200-Stekanker-Bar anchor_Mavotrans_R19: 120028_Ø20/M24-705
Phasing - Phase Created: New Construction
Structural - Rebar Cover: Rebar Cover Settings: Rebar Cover 1
